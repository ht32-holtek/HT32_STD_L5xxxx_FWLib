# Keil uVision project Project_52353.uvprojx, settings and files
target HT32 (ARM-ADS)
  device: HT32L52353 Holtek
  pack: Holtek.HT32_DFP.1.0.72
  cpu: IROM(0x00000000-0x0001FBFF) IRAM(0x20000000-0x20005FFF) CLOCK(8000000) CPUTYPE("Cortex-M0+")
  output: HT32 +hex
  AfterMake: fromelf --bin -o "!L.bin" "!L"
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: USE_HT32_DRIVER, USE_HT32L52353_SK, USE_HT32L52343_53, USE_MEM_HT32L52353
  c include: ..\;..\..\..\..\library\CMSIS\Include;..\..\..\..\library\Device\Holtek\HT32L5xxxx\Include;..\..\..\..\library\HT32L5xxxx_Driver\inc;..\..\..\..\library\HT32_USBD_Library\inc;..\..\..\..\utilities
  asm define: USE_HT32_CHIP=42, USE_LIBCFG_RAM_SIZE=0x6000
  library: MicroLIB
  link misc: --entry Reset_Handler
  group User
    ../: main.c ht32l5xxxx_01_it.c ht32_usbd_class.c ht32_usbd_descriptor.c
  group Config
    ../: _ht32_project_source.h ht32_board_config.h ht32l5xxxx_conf.h ht32l5xxxx_01_usbdconf.h
    ./: ht32_op.s HT32L5xxxx_01_DebugSupport.ini
  group CMSIS
    ../: system_ht32l5xxxx_01.c
  group MDK-ARM
    ./: startup_ht32l5xxxx_01.s
  group USBD_Library
    ../../../../library/HT32_USBD_Library/src/: ht32_usbd_core.c
  group Library
    ../../../../library/HT32L5xxxx_Driver/src/: ht32_cm0plus_misc.c ht32l5xxxx_adc.c ht32l5xxxx_aes.c ht32l5xxxx_bftm.c ht32l5xxxx_ckcu.c ht32l5xxxx_cmp.c ht32l5xxxx_crc.c ht32l5xxxx_div.c ht32l5xxxx_ertc.c ht32l5xxxx_exti.c ht32l5xxxx_flash.c ht32l5xxxx_gpio.c ht32l5xxxx_i2c.c ht32l5xxxx_mctm.c ht32l5xxxx_pdma.c ht32l5xxxx_pwrcu.c ht32l5xxxx_rstcu.c ht32l5xxxx_rng.c ht32l5xxxx_sci.c ht32l5xxxx_spi.c ht32l5xxxx_tm.c ht32l5xxxx_usart.c ht32l5xxxx_usbd.c ht32l5xxxx_wdt.c
  group Retarget
    ../../../../library/HT32L5xxxx_Driver/src/: ht32_retarget.c ht32_serial.c
  group Utilities
    ../../../../utilities/: ht32_board.c
    ../../../../utilities/common/: i2c_eeprom.c spi_flash.c spi_lcd.c
  group Doc
    ../: readme.txt
software components: HT32 Stack Usage Analysis:HT32 Stack Usage Analysis 1.0.0
