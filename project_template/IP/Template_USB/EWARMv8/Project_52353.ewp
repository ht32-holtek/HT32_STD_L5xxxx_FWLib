# IAR project Project_52353.ewp, settings and files
configuration HT32 (ARM, debug)
  General.OGChipSelectEditMenu: HT32L52353 Holtek HT32L52353
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: USE_HT32_DRIVER; USE_HT32L52353_SK; USE_HT32L52343_53; USE_MEM_HT32L52353
  ICCARM.CCIncludePath2: ..\; ..\..\..\..\library\HT32L5xxxx_Driver\inc; ..\..\..\..\library\CMSIS\Include; ..\..\..\..\library\Device\Holtek\HT32L5xxxx\Include; ..\..\..\..\library\HT32_USBD_Library\inc; ..\..\..\..\utilities
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: USE_HT32_CHIP=42; USE_LIBCFG_RAM_SIZE=0x6000
  OBJCOPY.OOCOutputFile: HT32.hex
  ILINK.IlinkOutputFile: HT32.out
  ILINK.IlinkIcfFile: linker.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group CMSIS
    ../: system_ht32l5xxxx_01.c
  group Config
    ../: ht32_board_config.h _ht32_project_source.h ht32l5xxxx_conf.h ht32l5xxxx_01_usbdconf.h
    ./: ht32_op.c
  group Doc
    ../: readme.txt
  group EWARM
    ./: startup_ht32l5xxxx_iar_01.s
  group Library
    ../../../../library/HT32L5xxxx_Driver/src/: ht32_cm0plus_misc.c ht32l5xxxx_adc.c ht32l5xxxx_aes.c ht32l5xxxx_bftm.c ht32l5xxxx_ckcu.c ht32l5xxxx_cmp.c ht32l5xxxx_crc.c ht32l5xxxx_div.c ht32l5xxxx_ertc.c ht32l5xxxx_exti.c ht32l5xxxx_flash.c ht32l5xxxx_gpio.c ht32l5xxxx_i2c.c ht32l5xxxx_mctm.c ht32l5xxxx_pdma.c ht32l5xxxx_pwrcu.c ht32l5xxxx_rstcu.c ht32l5xxxx_rng.c ht32l5xxxx_sci.c ht32l5xxxx_spi.c ht32l5xxxx_tm.c ht32l5xxxx_usart.c ht32l5xxxx_usbd.c ht32l5xxxx_wdt.c
  group Retarget
    ../../../../library/HT32L5xxxx_Driver/src/: ht32_retarget.c ht32_serial.c
  group USBD_Library
    ../../../../library/HT32_USBD_Library/src/: ht32_usbd_core.c
  group User
    ../: ht32_usbd_class.c ht32_usbd_descriptor.c ht32l5xxxx_01_it.c main.c
  group Utilities
    ../../../../utilities/: ht32_board.c
    ../../../../utilities/common/: i2c_eeprom.c spi_flash.c spi_lcd.c
