# IAR project Project_57241.ewp, settings and files
configuration HT32 (ARM, debug)
  General.OGChipSelectEditMenu: HT32L57241 Holtek HT32L57241
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: USE_HT32_DRIVER; USE_HT32L57241_SK; USE_HT32L57231_41; USE_MEM_HT32L57241
  ICCARM.CCIncludePath2: ..\; ..\..\..\..\library\HT32L5xxxx_Driver\inc; ..\..\..\..\library\CMSIS\Include; ..\..\..\..\library\Device\Holtek\HT32L5xxxx\Include; ..\..\..\..\library\HT32_USBD_Library\inc; ..\..\..\..\utilities
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: USE_HT32_CHIP=44; USE_LIBCFG_RAM_SIZE=0x2000
  OBJCOPY.OOCOutputFile: HT32.hex
  ILINK.IlinkOutputFile: HT32.out
  ILINK.IlinkIcfFile: linker.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group CMSIS
    ../: system_ht32l5xxxx_01.c
  group Config
    ../: ht32_board_config.h _ht32_project_source.h ht32l5xxxx_conf.h
    ./: ht32_op.c
  group Doc
    ../: readme.txt
  group EWARM
    ./: startup_ht32l5xxxx_iar_02.s
  group Library
    ../../../../library/HT32L5xxxx_Driver/src/: ht32_cm0plus_misc.c ht32l5xxxx_adc.c ht32l5xxxx_bftm.c ht32l5xxxx_ckcu.c ht32l5xxxx_crc.c ht32l5xxxx_div.c ht32l5xxxx_ertc.c ht32l5xxxx_exti.c ht32l5xxxx_flash.c ht32l5xxxx_gpio.c ht32l5xxxx_i2c.c ht32l5xxxx_lcd.c ht32l5xxxx_mctm.c ht32l5xxxx_pdma.c ht32l5xxxx_pwrcu.c ht32l5xxxx_rstcu.c ht32l5xxxx_spi.c ht32l5xxxx_tm.c ht32l5xxxx_usart.c ht32l5xxxx_wdt.c
  group Retarget
    ../../../../library/HT32L5xxxx_Driver/src/: ht32_retarget.c ht32_serial.c
  group User
    ../: ht32l5xxxx_01_it.c main.c
  group Utilities
    ../../../../utilities/: ht32_board.c
    ../../../../utilities/common/: i2c_eeprom.c spi_flash.c spi_lcd.c
